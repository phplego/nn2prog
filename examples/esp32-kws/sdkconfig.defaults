## examples/esp32-kws/sdkconfig.defaults
```kconfig
CONFIG_COMPILER_OPTIMIZATION_PERF=y
CONFIG_ESP_DEFAULT_CPU_FREQ_MHZ_240=y
CONFIG_FREERTOS_HZ=100
CONFIG_MAIN_TASK_STACK_SIZE=32768
```
